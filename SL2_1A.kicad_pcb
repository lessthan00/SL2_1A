# Repository lessthan00/SL2_1A

## KiCad design SL2_1A.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7: 10uF; C_1206_3216Metric
D1, D2: LED; LED_1206_3216Metric
D3: SMAJ6.5CA; D_SMA_TVS
F1: 5V1A; R_1206_3216Metric
R1, R2: 5.1KΩ; R_1206_3216Metric
U1: SL2.1A; SOP-16_3.9x9.9mm_P1.27mm
USB1, USB2, USB3, USB4: USB_A; USB_A_TE_292303-7_Horizontal
USB5: TYPE-C 16PIN 2MD(073); USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
X1: 12Mhz; Crystal_HC49-U_Vertical

Connections:
/USBA1_D+: U1.2 (DP4), USB1.3 (D+)
/USBA1_D-: U1.1 (DM4), USB1.2 (D-)
/USBA2_D+: U1.4 (DP3), USB2.3 (D+)
/USBA2_D-: U1.3 (DM3), USB2.2 (D-)
/USBA3_D+: U1.6 (DP2), USB3.3 (D+)
/USBA3_D-: U1.5 (DM2), USB3.2 (D-)
/USBA4_D+: U1.8 (DP1), USB4.3 (D+)
/USBA4_D-: U1.7 (DM1), USB4.2 (D-)
/USBC_D+: D2.2, U1.10 (DP), USB5.A6 (D+), USB5.B6 (D+)
/USBC_D-: D1.2, U1.9 (DM), USB5.A7 (D-), USB5.B7 (D-)
/VDD18: C7.1, U1.14 (VDD18)
/VDD33: C6.1, U1.13 (VDD33)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D1.1, D2.1, D3.1 (K), R1.1, R2.1, U1.12 (GND), USB1.4 (GND), USB1.5 (Shield), USB2.4 (GND), USB2.5 (Shield), USB3.4 (GND), USB3.5 (Shield), USB4.4 (GND), USB4.5 (Shield), USB5.A1 (GND), USB5.A12 (GND), USB5.B1 (GND), USB5.B12 (GND), USB5.S1 (SHIELD)
unnamed: F1.1, USB5.A4 (VBUS), USB5.A9 (VBUS), USB5.B4 (VBUS), USB5.B9 (VBUS)
unnamed: U1.16 (XIN), X1.1
unnamed: U1.15 (XOUT), X1.2
unnamed: R2.2, USB5.A5 (CC1)
unnamed: R1.2, USB5.B5 (CC2)
VBUS: C1.1, C2.1, C3.1, C4.1, C5.1, D3.2 (A), F1.2, U1.11 (VDD5), USB1.1 (VBUS), USB2.1 (VBUS), USB3.1 (VBUS), USB4.1 (VBUS)

Notes on the sheet:
基于SL2.0A的USB2.0hub typeC口带4个typeA口 --wsy

Board: 2 copper layers, 80.0 x 37.6 mm, 20 parts (3 on the bottom side), 19 nets.
